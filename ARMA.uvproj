# Keil uVision project ARMA.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ARMA
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup
    ./: startup_LPC17xx.s
  group Core
    ./scotlandyARM/: core_cm3.c core_cm3.h system_LPC17xx.c system_LPC17xx.h
  group Channel
    ./scotlandyARM/: channel.c
  group GLCD
    ./scotlandyARM/: GLCD_LPC1700.c
  group Timer
    ./scotlandyARM/: funct_timer.c IRQ_timer.c lib_timer.c
  group Ethernet
    ./scotlandyARM/: EMAC.c
  group TCP/IP
    ./scotlandyARM/: tcpip.c
  group Joystick
    ./scotlandyARM/: lib_joystick.c funct_joystick.c
  group Speaker
    ./scotlandyARM/: lib_speaker.c funct_speaker.c
  group Headers
    ./scotlandyARM/: LPC17xx.h EMAC.h GLCD.h tcpip.h type.h joystick.h channel.h speaker.h timer.h
    ../OneDrive/Banco dei Pugni/CAProj/L'Oscuro Grimorio/demo/TCPnet/Library/: Font_24x16.h
