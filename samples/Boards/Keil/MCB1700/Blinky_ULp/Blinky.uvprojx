# Keil uVision project Blinky.uvprojx, settings and files
target SWO Trace (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0-dev23
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Files
    ./: Blinky.c IRQ.c ITM_Retarget.c
  group Trace Configuration
    ./: LPC17xx_TP.ini
  group Documentation
    ./: Abstract.txt
target TracePort Trace (ARM-ADS)
  device: LPC1768 NXP
  cpu: as above
  output: Blinky
  c flags: Optim=1 wLevel=2
  c define: TRACE_PIN_ENABLE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target Instruction Trace (ARM-ADS)
  device: LPC1768 NXP
  cpu: as above
  output: Blinky
  c flags: Optim=1 wLevel=2
  c define: TRACE_PIN_ENABLE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 3.30.0, Board Support:A/D Converter 1.0.0, Board Support:LED 1.0.0, Device:GPIO 1.00, Device:PIN 1.00, Device:Startup 1.0.0
