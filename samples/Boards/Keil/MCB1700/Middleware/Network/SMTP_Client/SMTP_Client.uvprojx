# Keil uVision project SMTP_Client.uvprojx, settings and files
target LPC1758 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1758 NXP
  pack: Keil.LPC1700_DFP.2.3.0-dev23
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SMTP_Client
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source
    ./: SMTP_Client.c SMTP_Client_UIF.c
  group Documentation
    ./: Abstract.txt
target LPC1768 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0-dev23
  cpu: as above
  output: SMTP_Client
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:A/D Converter 1.0.0, Board Support:Graphic LCD 1.0.0, Board Support:LED 1.0.0, Network:CORE 6.7.0, Network:Interface:ETH 6.7.0, Network:Service:SMTP Client 6.7.0, Network:Socket:TCP 6.7.0, Network:Socket:UDP 6.7.0, CMSIS Driver:Ethernet MAC 2.9, CMSIS Driver:Ethernet PHY:DP83848C 6.1, CMSIS Driver:SPI:SSP 2.7, Device:GPDMA 1.2, Device:GPIO 1.1, Device:PIN 1.0, Device:Startup 1.0.0
