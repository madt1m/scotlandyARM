# Keil uVision project scotlandyARMp.uvprojx, settings and files
target ARMA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: scotlandyARMp
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group CMSIS
    ./: system_LPC17xx.h system_LPC17xx.c LPC17xx.h core_cm3.c core_cm3.h
  group Joystick
    ./: funct_joystick.c lib_joystick.c joystick.h
  group main
    ./: test.c
  group startup
    ./CMSIS/startup/arm/: startup_LPC17xx.s
